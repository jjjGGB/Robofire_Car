Commit message: add GICP relocalization

File: wheeltec_robot_urdf/urdf/mini_mec_robot.urdf (robot description, URDF)
Before this commit: robot mini_mec_robot, 7 links, 6 joints
Links:
- removed link livox_frame
Joints:
- removed joint laser_joint
